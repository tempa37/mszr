<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\USK_M_MX.ewp</path>
  </project>
  <batchBuild />
</workspace>
